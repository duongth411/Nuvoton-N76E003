# Keil uVision project prjCBAS.uvproj, settings and files
target prjCBAS (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: prjCBAS +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\material\N76E003_BSP_Keil_C51_V1.0.6\N76E003_BSP_Keil_C51_V1.0.6\Include;..\CBAS
  group main
    ./: main.h main.c
  group lib
    ../../material/N76E003_BSP_Keil_C51_V1.0.6/N76E003_BSP_Keil_C51_V1.0.6/Common/: Common.c
  group startup
    ../../material/N76E003_BSP_Keil_C51_V1.0.6/N76E003_BSP_Keil_C51_V1.0.6/Startup/: STARTUP.A51
  group New Group
    ./: port.h glbvar.h
