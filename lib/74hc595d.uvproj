# Keil uVision project 74hc595d.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: 74hc595d (library)
  c flags: Optimize=8 SizeSpeed=1
  group common
    ./: STARTUP.A51
    ../../../material/N76E003_BSP_Keil_C51_V1.0.6/N76E003_BSP_Keil_C51_V1.0.6/Common/: Common.c
  group 74hc595
    ./: 74hc595.c
  group header
    ../: port.h
